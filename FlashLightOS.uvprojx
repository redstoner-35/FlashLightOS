# Keil uVision project FlashLightOS.uvprojx, settings and files
target FlashLightOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HT32F52352_33QFN Holtek
  pack: Holtek.HT32_DFP.1.0.44
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x1FE00) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: FlashLightOS +hex
  c flags: Optim=4 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HT32_DRIVER, USE_HT32F52352_SK, USE_HT32F52342_52, USE_MEM_HT32F52352
  c misc: --locale=english
  c include: .\User\inc;.\MCUConfig;.\MDK-ARM;.\CMSIS\Core\Include;.\CMSIS\Include;.\Library\inc;.\Config;.\User
  asm define: USE_HT32_CHIP=4
  memory RVCT4: ROM 0x0 size 0x1fc00
  memory RVCT9: RAM 0x20000000 size 0x4000
  group User
    ./User/: main.c ht32f5xxxx_01_it.c delay.c MCUBeatTimer.c LinearTabOp.c
  group MCUConfig
    ./MCUConfig/: ht32_board_config.h ht32_op.s ht32f5xxxx_01_usbdconf.h ht32f5xxxx_02_usbdconf.h ht32f5xxxx_conf.h HT32F5xxxx_01_DebugSupport.ini
  group CMSIS
    ./CMSIS/: system_ht32f5xxxx_01.c
  group MDK-ARM
    ./MDK-ARM/: startup_ht32f5xxxx_01.s
  group Library
    ./Library/src/: ht32_cm0plus_misc.c ht32f5xxxx_adc.c ht32f5xxxx_bftm.c ht32f5xxxx_ckcu.c ht32f5xxxx_cmp.c ht32f5xxxx_crc.c ht32f5xxxx_ebi.c ht32f5xxxx_exti.c ht32f5xxxx_flash.c ht32f5xxxx_gpio.c ht32f5xxxx_i2c.c ht32f5xxxx_i2s.c ht32f5xxxx_mctm.c ht32f5xxxx_pdma.c ht32f5xxxx_pwrcu.c ht32f5xxxx_rstcu.c ht32f5xxxx_rtc.c ht32f5xxxx_sci.c ht32f5xxxx_spi.c ht32f5xxxx_tm.c ht32f5xxxx_usart.c ht32f5xxxx_usbd.c ht32f5xxxx_wdt.c
  group ConfFileMgmt
    ./ConfFileMgmt/: cfgfileop.c AES256.c runtimelogger.c selftestlogger.c logger.c FRU.c
  group I2C
    ./I2C/: I2CDrv.c PMBUS.c INA219.c AD5693R.c 24Cxx.c
  group SystemCommand
    ./Command/System/: cfgmgmt.c clear.c LoginLogout.c usrmod.c help.c reboot.c
  group ExtPeriphal
    ./ExtPeriphal/: LEDMgmt.c ADC.c SideKey.c PWMDIM.c LinearDIM.c BattMonitor.c FlashProt.c TempMonitor.c TempControl.c
    ./ModeLogic/: DeepSleep.c
  group Shell
    ./Shell/: CommandHandler.c CommandHistory.c CommandProcUtil.c UsartRxSupport.c UsartTxSupport.c UserIdleTimer.c HandlerEntry.c ParameterProcessor.c TinyShell.c
  group UserCommand
    ./Command/User/: ver.c imonadj.c logview.c logclr.c runlogview.c runlogcfg.c logbkup.c modeenacfg.c modeadvcfg.c modecurcfg.c strobecfg.c mostrancfg.c breathecfg.c thermalcfg.c modeporcfg.c battcfg.c customflashcfg.c modeview.c fruedit.c modepofcfg.c thermaltripcfg.c misccfg.c
  group ModeLogic
    ./User/inc/: modelogic.h
    ./ModeLogic/: ModeSwitchLogic.c OnOffSwitchLogic.c SpecialModeTimer.c BreathMode.c RampMode.c MorseCodeTransmitMode.c Customflash.c RandomFlash.c LinearFlash.c
  group Xmodem
    ./Xmodem/: XmodemRX.c XmodemTX.c XmodemDigestEncrypt.c XmodemInfo.c
  group Config
    ./Config/: FirmwareConf.h I2CAddr.h Pindefs.h LEDCode.txt
